<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Backup of example-icm20948.ewp</path>
  </project>
  <batchBuild/>
</workspace>


